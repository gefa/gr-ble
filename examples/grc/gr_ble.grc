options:
  parameters:
    generate_options: no_gui
    id: gr_ble
    output_language: python
    realtime_scheduling: '1'
    title: gr_ble
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: int(2402e6)
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {state: disabled}
- name: channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1000000 * (2402 + 2 * (channel))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '-1.5e6'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {state: disabled}
- name: gain_tx
  id: variable
  parameters:
    value: '80'
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: bar_periodic_msg_source_0
  id: bar_periodic_msg_source
  parameters:
    debug: 'False'
    interval: '1000'
    msg: pmt.intern(b'\xaa\xd6\xbe\x89\x8e\x8f\xc8\xa8\x4f\xe0\x6b\xdd\x1a\x77\x30\x17\x58\x9e\x24\x91\x8f\x27\x8b\xd8\xf0\xcc\x12\x7a\x94\xee\xdd\x5b\x70\xa6\xd6\x1a')
    num: '-1'
    quit: 'True'
  states: {state: disabled}
- name: ble_preamble_0
  id: ble_preamble
  parameters: {}
  states: {}
- name: ble_whiten_0
  id: ble_whiten
  parameters:
    chan_nbr: '37'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: gmsk_gain_mu
    mu: gmsk_mu
    omega_relative_limit: gmsk_omega_limit
    samples_per_symbol: gmsk_sps
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain_tx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_tx
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: 'True'
    dev_args: '""'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: sample_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_simple_squelch_cc_1, '0', digital_gmsk_demod_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [bar_periodic_msg_source_0, out, blocks_message_debug_0, print_pdu]
- [bar_periodic_msg_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [ble_preamble_0, out, ble_whiten_0, in]
- [ble_preamble_0, out, blocks_message_debug_0, print_pdu]
- [ble_whiten_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [blocks_socket_pdu_0, pdus, ble_preamble_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', zeromq_push_sink_0, '0']
- [digital_gmsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_1, '0']

metadata:
  file_format: 1
