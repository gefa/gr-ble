options:
  parameters:
    generate_options: no_gui
    id: bt4le
    output_language: python
    title: bt4le
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: gain_send
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: ble_preamble_0
  id: ble_preamble
  parameters: {}
  states: {}
- name: ble_whiten_0
  id: ble_whiten
  parameters:
    chan_nbr: '37'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain_send
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ble_preamble_0, out, ble_whiten_0, in]
- [ble_whiten_0, out, blocks_message_debug_0, print_pdu]
- [ble_whiten_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [blocks_socket_pdu_0, pdus, ble_preamble_0, in]
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
